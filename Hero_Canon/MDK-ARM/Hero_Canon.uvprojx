# Keil uVision project Hero_Canon.uvprojx, settings and files
target Hero_Canon (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Hero_Canon
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c gpio.c spi.c stm32f4xx_it.c dma.c can.c tim.c usart.c stm32f4xx_hal_msp.c bsp_flash.c bsp_imu.c calibrate.c controlTask.c imu_task.c pid.c remoteTask.c Rm_pid.c testTask.c gun.c ramp.c collect.c lifter.c stepper.c claw.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c
software components: CMSIS:CORE 4.3.0
